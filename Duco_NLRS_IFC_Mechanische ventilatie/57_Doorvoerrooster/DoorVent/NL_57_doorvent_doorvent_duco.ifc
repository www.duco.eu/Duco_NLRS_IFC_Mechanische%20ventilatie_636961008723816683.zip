Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:27:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:27:07 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{673835E7-1E7B-4913-9873-BAE559B66071}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:27:05 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:27:06 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:27:06 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: doorvent_duco_doorvent, NLRS_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco:doorvent_duco_doorvent:205087
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: NLRS_h4_aluminium, NLRS_n_plastic_zwart
Type - Constraints(Type) - Default Elevation: 200 mm
Type - Dimensions(Type) - NLRS_C_hoogte: 58 mm; NLRS_C_lengte: 436 mm; WT_V Roosterhoogte: 45 mm
Type - Identity Data(Type) - Assembly Code: 31.2; Description: DoorVent_luchtdoorvoerrooster_duco; Manufacturer: Duco; Model: DucoVent; NLRS_C_code_ETIM: Overstroomrooster; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; NLRS_C_code_fabrikant_product: ducovent; NLRS_C_code_gtin: -; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 26/02/2016; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V5; NLRS_C_description: DoorVent_luchtdoorvoerrooster_duco; NLRS_C_model: DucoVent; NLRS_C_revit_versie: 2016; NLRS_C_type_comments: luchtdoorvoerrooster; OmniClass Number: 3A(57.16.11); RS_C_fabrikant_artikelcode: DoorVent; Type Comments: luchtdoorvoerrooster; Type Name: doorvent_duco_doorvent; URL: http://www.duco.eu/producten/specificaties.cfm?prod=126&pid=3-126&cat=126; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_h4_aluminium; WT_V Binnenprofiel_materiaal: NLRS_h4_aluminium; WT_V Buitenprofiel_materiaal: NLRS_h4_aluminium; WT_V Eindkappen_materiaal: NLRS_n_plastic_zwart; WT_V Rooster_materiaal: NLRS_a_geperforeerd
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 1Pa: 0.165979 m3/s
Type - Model Properties(Type) - WT_I Deur_MAX diepte: 47 mm; WT_I Deur_MIN diepte: 37 mm; WT_I Geluidsniveauverschil Dne, W_in open stand: 32 dB; WT_I Kleur: F1 - RAL; WT_I Luchtdoorlaat: 0.007 m2
Type - Other(Type) - Category: Air Terminals; Family Name: NLRS_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: doorvent_duco_doorvent
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Deur_diepte: 37 mm
Dimensions - Area: 0.159529 m2; NLRS_C_diepte: 41 mm; Volume: 0.000968693 m3
Identity Data - Mark: 1
Mechanical - Flow - NLRS_M_debiet: 0.0685493 m3/s
Other - Category: Air Terminals; Family: NLRS_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent; Family and Type: NLRS_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent; Schedule Level: Level: Level 1; Type: NLRS_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent; Type Id: NLRS_57_AIR_FB_luchtdoorvoerrooster - doorvent_duco: doorvent_duco_doorvent
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
