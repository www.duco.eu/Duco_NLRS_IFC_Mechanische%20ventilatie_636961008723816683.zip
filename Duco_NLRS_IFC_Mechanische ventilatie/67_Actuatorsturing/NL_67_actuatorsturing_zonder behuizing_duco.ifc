Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:31:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:31:58 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{3B2A1EF4-935B-467F-8A22-67534B63B835}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:31:55 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:31:56 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:31:56 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcBuildingElementProxy: connector communication_gen (3)
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - Type Name: connector communication_gen
Type - Other(Type) - Category: Communication Devices; Family Name: NLRS_XX_GM_FB_connector communication_gen
Pset_BuildingElementProxyCommon - Reference: connector communication_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Other - Category: Communication Devices; Family: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; Family and Type: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; Type: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; Type Id: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; WT_c1 utility: no
Phasing - Phase Created: New Construction
Name (NLRS_XX_GM_FB_connector communication_gen:connector communication_gen:...) | Mark | WT_c1 Omschrijving
200842 | 6 | c2_2- of 3 puntssturing
200843 | 7 | c3_PWM out
200844 | 8 | c4_Duco Wired
