Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:31:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:31:55 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{CD9D4448-7E90-4870-AB5A-F97516323E84}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:31:53 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:31:53 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:31:53 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcBuildingElementProxy: connector communication_gen (3)
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - Type Name: connector communication_gen
Type - Other(Type) - Category: Communication Devices; Family Name: NLRS_XX_GM_FB_connector communication_gen
Pset_BuildingElementProxyCommon - Reference: connector communication_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Other - Category: Communication Devices; Family: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; Family and Type: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; Type: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; Type Id: NLRS_XX_GM_FB_connector communication_gen: connector communication_gen; WT_c1 utility: no
Phasing - Phase Created: New Construction
Name (NLRS_XX_GM_FB_connector communication_gen:connector communication_gen:...) | Mark | WT_c1 Omschrijving
200834 | 2 | c2_2- of 3 puntssturing
200835 | 3 | c3_PWM out
200836 | 4 | c4_Duco Wired

# IfcDistributionControlElement: actuatorsturing_duco_met behuizing, NLRS_67_COM_FB_actuatorsturing_duco:actuatorsturing_duco_met behuizing:200832
In: Level 1
Type - Classification: 67.1 (Uniformat)
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Dimensions(Type) - NLRS_C_breedte: 146 mm; NLRS_C_diepte: 58 mm; NLRS_C_hoogte: 80 mm
Type - Electrical(Type) - NLRS_E_c01_aantal_polen: 1; NLRS_E_c01_actief_vermogen: 0 W; NLRS_E_c01_arbeidsfactor: 1; NLRS_E_c01_belastingsklasse: HVAC; NLRS_E_c01_spanning: 220 V; NLRS_E_c01_subklasse_motor: yes
Type - Graphics(Type) - WT_V Zichtbaar: yes
Type - Identity Data(Type) - Assembly Code: 67.1; Description: actuatorsturing_duco_met behuizing; Manufacturer: Duco; Model: actuatorsturing; NLRS_C_code_ETIM: Elektrische aandrijving met regelklep rond luchtkanaal; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC003086&classVersion=1; NLRS_C_code_fabrikant_product: 0000-4195; NLRS_C_code_gtin: 5 4 2503715 007 1; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 26/02/2016; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V5; NLRS_C_description: actuatorsturing_duco_met behuizing; NLRS_C_model: actuatorsturing; NLRS_C_revit_versie: 2016; NLRS_C_type: met behuizing; NLRS_C_type_comments: actuatorsturing; Type Comments: actuatorsturing; Type Name: actuatorsturing_duco_met behuizing; URL: http://www.duco.eu; WT_I BaseKeynote: 67.10.10
Type - Model Properties(Type) - WT_I Aansluitingen: 2- of 3-puntssturing (3 aders); PWM out (2 aders); Duco Wired (5 aders); WT_I Communicatie: Wired; WT_I Kleur omkasting: Wit; WT_I Type: Actuatorsturing
Type - Other(Type) - Category: Communication Devices; Family Name: NLRS_67_COM_FB_actuatorsturing_duco; NLRS_E_c01_omschrijving: c1_elektrische connector; NLRS_E_c02_omschrijving: c2_2- of 3 puntssturing; NLRS_E_c03_omschrijving: c3_PWM out; NLRS_E_c04_omschrijving: c4_Duco Wired
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V 2- of 3 puntssturing: yes; WT_V Duco Wired: yes; WT_V PWM out: yes
Dimensions - Area: 0.024788 m2; Volume: 0.00067744 m3
Electrical - Circuiting - Electrical Data: c1_elektrische connector 220 V/1-0 VA
Graphics - WT_V Positie annotatie x: 0; WT_V Positie annotatie y: 0; WT_V Verschuiving annotatie x: 0 mm; WT_V Verschuiving annotatie y: 0 mm
Identity Data - Mark: 1
Other - Category: Communication Devices; Family: NLRS_67_COM_FB_actuatorsturing_duco: actuatorsturing_duco_met behuizing; Family and Type: NLRS_67_COM_FB_actuatorsturing_duco: actuatorsturing_duco_met behuizing; Schedule Level: Level: Level 1; Type: NLRS_67_COM_FB_actuatorsturing_duco: actuatorsturing_duco_met behuizing; Type Id: NLRS_67_COM_FB_actuatorsturing_duco: actuatorsturing_duco_met behuizing
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
