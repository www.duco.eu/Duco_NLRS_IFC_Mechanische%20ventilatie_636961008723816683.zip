Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:31:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:31:01 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{1ADA76B2-17D2-4F1A-869C-C178BBC33444}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:31:00 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:31:01 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:31:01 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138, NLRS_59_DUA_UN_regelklep - set iav_duco:regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138:201266
In: Level 1
Type - PredefinedType: CONTROLDAMPER; Classification: 57.10.90.80 (Uniformat); Material: NLRS_x_rgb 255 255 255 T00 wit_gen, NLRS_x_rgb 000 149 150 T00 groen_gen
Type - Constraints(Type) - ZZZ_Behuizing_FamilyType_Duct Accessories: standard
Type - Dimensions(Type) - NLRS_C_breedte: 220 mm; NLRS_C_diepte: 138 mm; NLRS_C_hoogte: 183 mm
Type - Electrical(Type) - NLRS_E_c01_aantal_fasegeleiders: 1; NLRS_E_c01_actief_vermogen: 7 W; NLRS_E_c01_arbeidsfactor: 1; NLRS_E_c01_belastingsklasse: HVAC; NLRS_E_c01_schijnbaar_vermogen: 24 W; NLRS_E_c01_spanning: 24 V; NLRS_E_c01_stroom: 1 A; NLRS_E_c01_subklasse_motor: yes; WT_I Stand-By vermogen: 0.4 W
Type - Identity Data(Type) - Assembly Code: 57.10.90.80; Description: duco_set intelli air valve - regelklep sensorless; Manufacturer: Duco; Model: Set Intelli Air Valve; NLRS_C_code_ETIM: Regelklep rond luchtkanaal; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC011268&classVersion=3; NLRS_C_code_fabrikant_product: -; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 06/02/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V1; NLRS_C_description: duco_set intelli air valve - regelklep sensorless; NLRS_C_IFC_versie: 2x3; NLRS_C_model: Set Intelli Air Valve; NLRS_C_revit_versie: 2016; NLRS_C_type: Regelklep Sensorless; NLRS_C_type_comments: Regelklep; OmniClass Number: 23.75.70.14.34; OmniClass Title: Air Duct Accessories; Type Comments: Regelklep; Type Name: regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138; URL: http://www.duco.eu; WT_I BaseKeynote: 31.20
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_x_rgb 000 149 150 T00 groen_gen; NLRS_C_materiaal_01: NLRS_x_rgb 000 149 150 T00 groen_gen; NLRS_C_materiaal_02: NLRS_x_rgb 255 255 255 T00 wit_gen
Type - Mechanical(Type) - NLRS_M_c01_diameter: 160 mm
Type - Model Properties(Type) - NLRS_S_gewicht_bruto: 0.628; WT_I Communicatie: Wired met bovenliggende master (indien van toepassing), RF met onderliggende slave componenten; WT_I Toepasbaar in de volgende systemen: Duco CO2 System Collectief, Duco Comfort Plus System Collectief, Duco Tronic System Collectief, Duco Tronic Plus System Collectief
Type - Other(Type) - Category: Duct Accessories; Family Name: NLRS_59_DUA_UN_regelklep - set iav_duco; NLRS_E_c03_omschrijving: c03_connector; NLRS_M_c01_omschrijving: c01_aansluiting; NLRS_M_c02_omschrijving: c02_aansluiting
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.125949 m2; Size: 160 mmø-160 mmø; Volume: 0.0058858 m3
Identity Data - Mark: 7
Insulation - Insulation Thickness: 0 mm; Overall Size: 160 mmø-160 mmø
Lining - Free Size: 160 mmø-160 mmø; Lining Thickness: 0 mm
Mechanical - System Classification: Undefined,Power
Other - Category: Duct Accessories; Family: NLRS_59_DUA_UN_regelklep - set iav_duco: regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138; Family and Type: NLRS_59_DUA_UN_regelklep - set iav_duco: regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138; Type: NLRS_59_DUA_UN_regelklep - set iav_duco: regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138; Type Id: NLRS_59_DUA_UN_regelklep - set iav_duco: regelklep sensorless - 160 mm_duco_set iav_bxhxd 220x183x138
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
