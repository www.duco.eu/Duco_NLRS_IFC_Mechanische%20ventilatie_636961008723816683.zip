Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:27:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:27:28 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{66BE102A-EE79-4EEF-8486-0842596DCAB2}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:27:26 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:27:26 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:27:26 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: toevoerventiel - vierkant xl_duco_ducovent design, NLRS_57_AIR_FB_toevoerventiel - ducovent design_duco:toevoerventiel - vierkant xl_duco_ducovent design:201418
In: Level 1
Type - PredefinedType: GRILLE; Material: RSen_n6_PVC_white
Type - Constraints(Type) - Default Elevation: 2000 mm
Type - Dimensions(Type) - NLRS_C_breedte: 215 mm; NLRS_C_diameter: 0 mm; NLRS_C_diepte: 22 mm; NLRS_C_hoogte: 73.5 mm; NLRS_M_c01_diameter: 125 mm; WT_V Verbindingsdiepte: 52 mm
Type - Identity Data(Type) - Cost: 0; Description: duco_ducovent design_toevoerventiel - vierkant xl; Manufacturer: Duco; Model: ducovent design; NLRS_C_code_ETIM: Overstroomrooster; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; NLRS_C_code_fabrikant_product: 4226; NLRS_C_code_gtin: -; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 06/02/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V1; NLRS_C_description: duco_ducovent design_toevoerventiel - vierkant xl; NLRS_C_model: ducovent design; NLRS_C_revit_versie: 2016; NLRS_C_type: vierkant xl; NLRS_C_type_comments: toevoerventiel; Type Comments: toevoerventiel; Type Name: toevoerventiel - vierkant xl_duco_ducovent design; URL: http://www.duco.eu/producten/luchtafvoer/afvoerventielen/nl-be-ducoventdesign; WT_I BaseKeynote: 57.10.90.1
Type - Materials and Finishes(Type) - NLRS_C_materiaal: RSen_n6_PVC_white
Type - Mechanical - Flow(Type) - Max Flow: 0.735722 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveau: <15 dB(A) at 50 m3/h; WT_I Installatiehoogte: min. 18 cm above the floor; WT_I Kleur: Ral 9010_white; WT_I Montage op minimum: minimium 60 cm from the wall and ceiling
Type - Other(Type) - Category: Air Terminals; Family Name: NLRS_57_AIR_FB_toevoerventiel - ducovent design_duco; NLRS_M_c01_drukverlies_statisch: 0 Pa; NLRS_M_c01_omschrijving: c01_Toevoer; NLRS_M_c01_radius: 62.5 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: toevoerventiel - vierkant xl_duco_ducovent design
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.07783 m2; Size: 125 mmø; Volume: 0.00339754 m3
Identity Data - Mark: 2
Mechanical - System Classification: Supply Air
Mechanical - Flow - Flow: 0 m3/s; NLRS_M_debiet: 0 m3/s; WT_I Maximale stroomsnelheid: OK
Other - Category: Air Terminals; Family: NLRS_57_AIR_FB_toevoerventiel - ducovent design_duco: toevoerventiel - vierkant xl_duco_ducovent design; Family and Type: NLRS_57_AIR_FB_toevoerventiel - ducovent design_duco: toevoerventiel - vierkant xl_duco_ducovent design; NLRS_M_c01_debiet: 0 m3/s; Schedule Level: Level: Level 1; Type: NLRS_57_AIR_FB_toevoerventiel - ducovent design_duco: toevoerventiel - vierkant xl_duco_ducovent design; Type Id: NLRS_57_AIR_FB_toevoerventiel - ducovent design_duco: toevoerventiel - vierkant xl_duco_ducovent design
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
