Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:27:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:27:17 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{3D144307-23A4-4712-B440-356921C37FBD}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:27:14 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:27:14 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:27:14 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: basic - 75m3/h_duco, NLRS_57_AIR_FB_toevoerventiel - ducovent basic_duco:basic - 75m3/h_duco:201079
In: Level 1
Type - PredefinedType: GRILLE
Type - Constraints(Type) - Default Elevation: 2000 mm
Type - Dimensions(Type) - NLRS_C_breedte: 0 mm; NLRS_C_diameter: 200 mm; NLRS_C_diepte: 50 mm; NLRS_C_hoogte: 0 mm; NLRS_E_c01_diameter: 125 mm; WT_V Aansluitdiepte: 20 mm
Type - Identity Data(Type) - Cost: 0; Description: duco_toevoerventiel_basic; Manufacturer: Duco; Model: Ducovent Basic; NLRS_C_code_ETIM: Overstroomrooster; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; NLRS_C_code_fabrikant_product: 0000-4178; NLRS_C_code_gtin: 5 4 2503715 017 0; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 26/02/2016; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V5; NLRS_C_description: duco_toevoerventiel_basic; NLRS_C_model: Ducovent Basic; NLRS_C_revit_versie: 2016; NLRS_C_type_comments: toevoerventiel; Type Comments: toevoerventiel; Type Name: basic - 75m3/h_duco; URL: http://www.duco-professionals.eu/Wes/Website/nl-NL/Search?recordsPerPage=5&sortBy=relevance&term=ducovent; WT_I BaseKeynote: 57.10.90.1
Type - Mechanical - Flow(Type) - Max Flow: 0.735722 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveau: -; WT_I Kleur: Ral 9010_wit; WT_I Montagehoogte: min. 18 cm boven de vloer; WT_I Montage op minimium: minimium 60 cm van de muur en plafond
Type - Other(Type) - Category: Air Terminals; Family Name: NLRS_57_AIR_FB_toevoerventiel - ducovent basic_duco; NLRS_M_c01_drukverlies_statisch: 0 Pa; NLRS_M_c01_omschrijving: c01_Toevoer; NLRS_M_c01_radius: 62.5 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: basic - 75m3/h_duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0549737 m2; Size: 125 mmø; Volume: 0.00235608 m3
Identity Data - Mark: 1
Mechanical - System Classification: Supply Air
Mechanical - Flow - Flow: 0 m3/s; NLRS_M_debiet: 0 m3/s; WT_I Maximaal debiet: OK
Other - Category: Air Terminals; Family: NLRS_57_AIR_FB_toevoerventiel - ducovent basic_duco: basic - 75m3/h_duco; Family and Type: NLRS_57_AIR_FB_toevoerventiel - ducovent basic_duco: basic - 75m3/h_duco; NLRS_M_c01_debiet: 0 m3/s; Schedule Level: Level: Level 1; Type: NLRS_57_AIR_FB_toevoerventiel - ducovent basic_duco: basic - 75m3/h_duco; Type Id: NLRS_57_AIR_FB_toevoerventiel - ducovent basic_duco: basic - 75m3/h_duco
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
