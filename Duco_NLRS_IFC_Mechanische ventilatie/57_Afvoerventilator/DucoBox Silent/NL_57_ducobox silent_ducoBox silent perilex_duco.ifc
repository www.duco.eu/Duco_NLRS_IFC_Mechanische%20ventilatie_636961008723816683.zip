Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:28:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:28:12 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{268F5682-93B0-4BF7-96C2-1BB21FEE3AB9}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:28:10 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:28:11 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:28:11 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcEnergyConversionDevice: ducoBox silent perilex_duco, NLRS_57_ME_FB_afvoerventilator ducobox silent_duco:ducoBox silent perilex_duco:205575
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.10.10 (Uniformat); Material: NLRS_x_rgb 000 149 150 T00 groen_gen, NLRS_x_rgb 255 255 255 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Onderhoudszone_diepte: 400 mm
Type - Dimensions(Type) - NLRS_C_breedte: 480 mm; NLRS_C_diepte: 195 mm; NLRS_C_hoogte: 480 mm
Type - Electrical(Type) - NLRS_E_c01_aantal_polen: 1; NLRS_E_c01_arbeidsfactor: 1; NLRS_E_c01_belastingsklasse: HVAC; NLRS_E_c01_schijnbaar_vermogen: 230 W; NLRS_E_c01_spanning: 230 V; NLRS_E_c01_stroom: 1 A; NLRS_E_c01_subklasse_motor: no
Type - Identity Data(Type) - Assembly Code: 57.10.10; Description: ducobox silent perilex_duco; Manufacturer: Duco; Model: DucoBox Silent Perilex; NLRS_C_code_ETIM: Woonhuisventilator; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; NLRS_C_code_fabrikant_product: 0000-4225; NLRS_C_code_gtin: 5425037150699; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 26/02/2016; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V5; NLRS_C_description: ducobox silent perilex_duco; NLRS_C_model: DucoBox Silent Perilex; NLRS_C_revit_versie: 2016; NLRS_C_type_comments: afvoerventilator; OmniClass Number: 3A(57.31.11); Type Comments: afvoerventilator; Type Name: ducoBox silent perilex_duco; URL: http://www.duco.eu/architects/nl-nl-producten/nl-nl-luchtafvoer/nl-nl-mechanische-afvoer/nl-nl-ducoboxsilent; WT_I BaseKeynote: 57.10.10
Type - Mechanical(Type) - WT_V Capaciteit: 3.92385 m3/s; WT_V Opvoerhoogte: 150 Pa
Type - Model Properties(Type) - WT_I Afvoer_regeling: Centraal; WT_I Geluidsvermogen_aanzuig: 57.5; WT_I Geluidsvermogen_afstraling kast: 46.5; WT_I Gepatenteerd regelkleppensysteem: no
Type - Other(Type) - Category: Mechanical Equipment; Family Name: NLRS_57_ME_FB_afvoerventilator ducobox silent_duco; NLRS_E_c01_omschrijving: c01_Elektrische aansluiting; NLRS_E_c02_omschrijving: c02_Communication aansluiting; NLRS_M_c01_omschrijving: c01_Afblaas; NLRS_M_c01_radius: 62.5 mm; NLRS_M_c02_omschrijving: c02_Extractie 1; NLRS_M_c03_omschrijving: c03_Extractie 2; NLRS_M_c04_omschrijving: c04_Extractie 3; NLRS_M_c05_omschrijving: c05_Extractie 4; NLRS_M_c06_omschrijving: c06_Extractie 5; NLRS_M_c06_straal: 62.5 mm; NLRS_M_c07_omschrijving: c07_Extractie 6; NLRS_M_c07_straal: 62.5 mm; NLRS_M_c08_omschrijving: c08_Extractie 7; NLRS_M_c08_straal: 62.5 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: ducoBox silent perilex_duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Aansturing_Draadloos: no; WT_V Aansturing_Opsteek IQ: yes; WT_V Aansturing_Opsteek PWM print + externe IQ: no; WT_V CO2 boxsensor: no; WT_V Communication Print: no; WT_V Communication Print_zichtbaar: no; WT_V EasySwitch: no; WT_V Eindkap zichtbaar_1: yes; WT_V Eindkap zichtbaar_2: yes; WT_V Eindkap zichtbaar_3: yes; WT_V Eindkap zichtbaar_4: yes; WT_V Eindkap zichtbaar_5: yes; WT_V Eindkap zichtbaar_6: yes; WT_V Eindkap zichtbaar_7: yes; WT_V Vocht boxsensor: no
Dimensions - Area: 1.1348 m2; Volume: 0.044928 m3
Graphics - WT_V Onderhoudszone zichtbaar: no
Identity Data - Mark: 2
Mechanical - System Classification: Return Air,Exhaust Air,Return Air,Power,Communication,Return Air
Mechanical - Flow - NLRS_M_debiet: 0 m3/s
Other - Category: Mechanical Equipment; Family: NLRS_57_ME_FB_afvoerventilator ducobox silent_duco: ducoBox silent perilex_duco; Family and Type: NLRS_57_ME_FB_afvoerventilator ducobox silent_duco: ducoBox silent perilex_duco; NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c02_debiet: 0 m3/s; NLRS_M_c02_radius: 62.5 mm; NLRS_M_c03_debiet: 0 m3/s; NLRS_M_c03_straal: 62.5 mm; NLRS_M_c04_debiet: 0 m3/s; NLRS_M_c04_straal: 62.5 mm; NLRS_M_c05_debiet: 0 m3/s; NLRS_M_c05_straal: 62.5 mm; NLRS_M_c06_debiet: 0 m3/s; NLRS_M_c07_debiet: 0 m3/s; NLRS_M_c08_debiet: 0 m3/s; Schedule Level: Level: Level 1; Type: NLRS_57_ME_FB_afvoerventilator ducobox silent_duco: ducoBox silent perilex_duco; Type Id: NLRS_57_ME_FB_afvoerventilator ducobox silent_duco: ducoBox silent perilex_duco
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
