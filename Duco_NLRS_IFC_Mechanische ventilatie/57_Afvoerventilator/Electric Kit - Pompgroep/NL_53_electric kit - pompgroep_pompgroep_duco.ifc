Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:26:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:26:22 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{957DBAEF-F7AA-4328-B9FA-D1EF7E4856E7}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:26:20 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:26:20 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:26:20 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: pompgroep_duco_bxhxd 240x310x217, NLRS_53_ME_FB_ducobox eco - electric kit - pompgroep_duco:pompgroep_duco_bxhxd 240x310x217:207999
In: Level 1
Type - Classification: 56.10.10 (Uniformat); Material: NLRS_x_rgb 255 255 255 T00 wit_gen, NLRS_x_rgb 105 16 8 T00 rood_gen, NLRS_x_rgb 0 0 255 T00 blauw_gen, NLRS_x_rgb 20 20 20 T00 zwart_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Dimensions(Type) - NLRS_C_breedte: 240 mm; NLRS_C_diepte: 217 mm; NLRS_C_hoogte: 310 mm
Type - Electrical Engineering(Type) - NLRS_E_c01_aantal_polen: 1; NLRS_E_c01_arbeidsfactor: 0; NLRS_E_c01_belastingsklasse: HVAC; NLRS_E_c01_schijnbaar_vermogen: 0 W; NLRS_E_c01_spanning: 0 V; NLRS_E_c01_stroom: 0 A; NLRS_E_c01_subklasse_motor: yes
Type - Identity Data(Type) - Assembly Code: 56.10.10; Description: pompgroep_duco; Model: -; NLRS_C_code_artikel: 0000-4424_DucoBox Eco All Electric Kit AE1_Pompgroep voor LTV; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 20/12/2018; NLRS_C_content_datum_uitgifte: 20/12/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: 1.0.0; NLRS_C_description: pompgroep_duco; NLRS_C_model: -; NLRS_C_revit_versie: 2016; NLRS_C_type: -; NLRS_C_type_comments: -; Type Comments: -; Type Name: pompgroep_duco_bxhxd 240x310x217; WT_I BaseKeynote: 56.10.10
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_x_rgb 20 20 20 T00 zwart_gen
Type - Other(Type) - Category: Mechanical Equipment; Family Name: NLRS_53_ME_FB_ducobox eco - electric kit - pompgroep_duco; NLRS_E_c01_omschrijving: c01_el; NLRS_P_c01_diameter: 25 mm; NLRS_P_c01_omschrijving: c01_CVr; NLRS_P_c02_diameter: 25 mm; NLRS_P_c02_omschrijving: c02_CVv; NLRS_P_c03_diameter: 25 mm; NLRS_P_c03_omschrijving: c03_CVr; NLRS_P_c04_diameter: 25 mm; NLRS_P_c04_omschrijving: c04_CVv; WT_V P_c01_rotatie uit vlak: 0 deg; WT_V P_c01_vlak: 1; WT_V P_c01_X: 45 mm; WT_V P_c01_Y: 33.5 mm; WT_V P_c01_Z: 0 mm; WT_V P_c02_rotatie uit vlak: 0 deg; WT_V P_c02_vlak: 1; WT_V P_c02_X: -45 mm; WT_V P_c02_Y: 33.5 mm; WT_V P_c02_Z: 0 mm; WT_V P_c03_rotatie uit vlak: 0 deg; WT_V P_c03_vlak: 2; WT_V P_c03_X: -45 mm; WT_V P_c03_Y: 33.5 mm; WT_V P_c03_Z: 0 mm; WT_V P_c04_rotatie uit vlak: 0 deg; WT_V P_c04_vlak: 2; WT_V P_c04_X: 45 mm; WT_V P_c04_Y: 33.5 mm; WT_V P_c04_Z: 0 mm
Pset_BuildingElementProxyCommon - Reference: pompgroep_duco_bxhxd 240x310x217
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 1.156 m2; Volume: 0.096123 m3
Identity Data - Mark: 1
Mechanical - System Classification: Hydronic Return,Hydronic Supply,Hydronic Return,Hydronic Supply,Power
Other - Category: Mechanical Equipment; Family: NLRS_53_ME_FB_ducobox eco - electric kit - pompgroep_duco: pompgroep_duco_bxhxd 240x310x217; Family and Type: NLRS_53_ME_FB_ducobox eco - electric kit - pompgroep_duco: pompgroep_duco_bxhxd 240x310x217; NLRS_P_c01_volumestroom: 0 m3/s; NLRS_P_c02_volumestroom: 0 m3/s; NLRS_P_c03_volumestroom: 0 m3/s; NLRS_P_c04_volumestroom: 0 m3/s; Schedule Level: Level: Level 1; Type: NLRS_53_ME_FB_ducobox eco - electric kit - pompgroep_duco: pompgroep_duco_bxhxd 240x310x217; Type Id: NLRS_53_ME_FB_ducobox eco - electric kit - pompgroep_duco: pompgroep_duco_bxhxd 240x310x217
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
