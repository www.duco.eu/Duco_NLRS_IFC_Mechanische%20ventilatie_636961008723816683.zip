Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:31:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:31:37 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{7A19FFA0-3CCA-4118-8B22-636A534E5D55}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:31:35 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:31:36 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:31:36 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: platte sifon_duco, NLRS_59_ME_FB_platte sifon - SH_duco:platte sifon_duco:198372
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: NLRS_x_rgb 248 248 248 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 0 mm
Type - Dimensions(Type) - NLRS_C_breedte: 64 mm; NLRS_C_diameter: 32 mm; NLRS_C_hoogte: 64 mm; NLRS_C_lengte: 252 mm
Type - Identity Data(Type) - Assembly Code: 67.10.10; Description: platte sifon_duco; Manufacturer: Duco; Model: sifon; NLRS_C_code_artikel: 0000-4376; NLRS_C_code_ETIM: Woonhuisventilator; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; NLRS_C_code_gtin: -; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 20/12/2018; NLRS_C_content_datum_uitgifte: 20/12/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: 1.0.0; NLRS_C_description: platte sifon_duco; NLRS_C_IFC_versie: 2x3; NLRS_C_model: sifon; NLRS_C_revit_versie: 2016; NLRS_C_type: platte; NLRS_C_type_comments: duco_platte sifon; OmniClass Number: 23.80.50.14; OmniClass Title: Plug Connectors; Type Comments: duco_platte sifon; Type Name: platte sifon_duco; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-boxsensor; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_x_rgb 248 248 248 T00 wit_gen
Type - Other(Type) - Category: Mechanical Equipment; Family Name: NLRS_59_ME_FB_platte sifon - SH_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0281007 m2; Volume: 0.000523929 m3
Identity Data - Mark: 1
Other - Category: Mechanical Equipment; Family: NLRS_59_ME_FB_platte sifon - SH_duco: platte sifon_duco; Family and Type: NLRS_59_ME_FB_platte sifon - SH_duco: platte sifon_duco; Schedule Level: Level: Level 1; Type: NLRS_59_ME_FB_platte sifon - SH_duco: platte sifon_duco; Type Id: NLRS_59_ME_FB_platte sifon - SH_duco: platte sifon_duco
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
