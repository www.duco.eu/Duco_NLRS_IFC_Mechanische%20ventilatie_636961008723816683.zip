Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:26:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:26:12 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{D209024A-28CB-44B9-8616-EC11F206A06F}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:26:10 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:26:10 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:26:10 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: buffervat - 300l_duco_dxh 797x1340, NLRS_53_ME_FB_ducobox eco - electric kit - buffervat_duco:buffervat - 300l_duco_dxh 797x1340:208976
In: Level 1
Type - Classification: 53.30.10.10 (Uniformat); Material: NLRS_x_rgb 20 20 20 T00 zwart_gen, NLRS_x_rgb 000 149 150 T00 groen_gen, NLRS_x_rgb 255 255 255 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Dimensions(Type) - NLRS_C_breedte: 0 mm; NLRS_C_diameter: 797 mm; NLRS_C_diepte: 0 mm; NLRS_C_hoogte: 1340 mm
Type - Electrical Engineering(Type) - NLRS_E_c01_aantal_polen: 1; NLRS_E_c01_arbeidsfactor: 0; NLRS_E_c01_belastingsklasse: HVAC; NLRS_E_c01_schijnbaar_vermogen: 0 W; NLRS_E_c01_spanning: 0 V; NLRS_E_c01_stroom: 0 A; NLRS_E_c01_subklasse_motor: yes
Type - Identity Data(Type) - Assembly Code: 53.30.10.10; Description: buffervat_duco; Model: 300L; NLRS_C_code_artikel: 0000-4424_DucoBox Eco All Electric Kit AE1_Buffervat 300L; NLRS_C_code_ETIM: Boiler storage tank; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010184&classVersion=3; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 20/12/2018; NLRS_C_content_datum_uitgifte: 20/12/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: 1.0.0; NLRS_C_description: buffervat_duco; NLRS_C_model: 300L; NLRS_C_revit_versie: 2016; NLRS_C_type: -; NLRS_C_type_comments: -; Type Comments: -; Type Name: buffervat - 300l_duco_dxh 797x1340; WT_I BaseKeynote: 53.30.10.10
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_x_rgb 255 255 255 T00 wit_gen; WT_V Maintenance zones_materiaal: NLRS_x_rgb 255 255 255 T00 wit_gen
Type - Other(Type) - Category: Mechanical Equipment; Family Name: NLRS_53_ME_FB_ducobox eco - electric kit - buffervat_duco; NLRS_E_c01_omschrijving: c01_el; NLRS_E_c02_omschrijving: c02_control; NLRS_E_c03_omschrijving: c03_control; NLRS_P_c01_diameter: 25 mm; NLRS_P_c01_omschrijving: c01_HW; NLRS_P_c02_diameter: 25 mm; NLRS_P_c02_omschrijving: c02_CVv; NLRS_P_c03_diameter: 25 mm; NLRS_P_c03_omschrijving: c03_KW; NLRS_P_c04_diameter: 25 mm; NLRS_P_c04_omschrijving: c04_CVv; NLRS_P_c05_diameter: 25 mm; NLRS_P_c05_omschrijving: c05_CHr; NLRS_P_c06_diameter: 25 mm; NLRS_P_c06_omschrijving: c06_CHs; NLRS_P_c07_diameter: 25 mm; NLRS_P_c07_omschrijving: c07_CHr; WT_V P_c01_rotatie uit vlak: 0 deg; WT_V P_c01_vlak: 1; WT_V P_c01_X: 0 mm; WT_V P_c01_Y: 0 mm; WT_V P_c01_Z: 0 mm; WT_V P_c02_rotatie uit vlak: 0 deg; WT_V P_c02_vlak: 6; WT_V P_c02_X: 0 mm; WT_V P_c02_Y: -180 mm; WT_V P_c02_Z: 0 mm; WT_V P_c03_rotatie uit vlak: 0 deg; WT_V P_c03_vlak: 6; WT_V P_c03_X: 0 mm; WT_V P_c03_Y: -445 mm; WT_V P_c03_Z: 0 mm; WT_V P_c04_rotatie uit vlak: 0 deg; WT_V P_c04_vlak: 5; WT_V P_c04_X: 0 mm; WT_V P_c04_Y: 363 mm; WT_V P_c04_Z: 0 mm; WT_V P_c05_rotatie uit vlak: 0 deg; WT_V P_c05_vlak: 5; WT_V P_c05_X: 0 mm; WT_V P_c05_Y: 90 mm; WT_V P_c05_Z: 0 mm; WT_V P_c06_rotatie uit vlak: 0 deg; WT_V P_c06_vlak: 5; WT_V P_c06_X: 0 mm; WT_V P_c06_Y: -180 mm; WT_V P_c06_Z: 0 mm; WT_V P_c07_rotatie uit vlak: 0 deg; WT_V P_c07_vlak: 5; WT_V P_c07_X: 0 mm; WT_V P_c07_Y: -445 mm; WT_V P_c07_Z: 0 mm
Pset_BuildingElementProxyCommon - Reference: buffervat - 300l_duco_dxh 797x1340
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 27.1368 m2; Volume: 8.32913 m3
Graphics - WT_V Onderhoudszone zichtbaar: no
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Hydronic Supply,Domestic Cold Water,Hydronic Supply,Hydronic Return,Hydronic Supply,Hydronic Return,Controls,Power,Controls
Other - Category: Mechanical Equipment; Family: NLRS_53_ME_FB_ducobox eco - electric kit - buffervat_duco: buffervat - 300l_duco_dxh 797x1340; Family and Type: NLRS_53_ME_FB_ducobox eco - electric kit - buffervat_duco: buffervat - 300l_duco_dxh 797x1340; NLRS_P_c01_volumestroom: 0 m3/s; NLRS_P_c02_volumestroom: 0 m3/s; NLRS_P_c03_volumestroom: 0 m3/s; NLRS_P_c04_volumestroom: 0 m3/s; NLRS_P_c05_volumestroom: 0 m3/s; NLRS_P_c06_volumestroom: 0 m3/s; NLRS_P_c07_volumestroom: 0 m3/s; Schedule Level: Level: Level 1; Type: NLRS_53_ME_FB_ducobox eco - electric kit - buffervat_duco: buffervat - 300l_duco_dxh 797x1340; Type Id: NLRS_53_ME_FB_ducobox eco - electric kit - buffervat_duco: buffervat - 300l_duco_dxh 797x1340
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
