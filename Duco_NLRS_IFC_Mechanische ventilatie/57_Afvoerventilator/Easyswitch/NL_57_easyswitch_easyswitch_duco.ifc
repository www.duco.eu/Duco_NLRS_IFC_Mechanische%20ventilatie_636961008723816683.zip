Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:28:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:28:20 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{85D6D3DC-013C-4F22-95AF-7C4CAE161DFA}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:28:17 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:28:18 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:28:18 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: easyswitch_duco, NLRS_57_ME_FB_easyswitch - SH_duco:easyswitch_duco:198231
In: Level 1
Type - Classification: 57.21 (Uniformat); Material: NLRS_x_rgb 000 149 150 T00 groen_gen
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Dimensions(Type) - NLRS_C_breedte: 485 mm; NLRS_C_hoogte: 485 mm
Type - Identity Data(Type) - Assembly Code: 57.21; Description: EasySwitch_Duco; Manufacturer: Duco; Model: EasySwitch; NLRS_C_code_ETIM: Woonhuisventilator; NLRS_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; NLRS_C_code_fabrikant_product: 0000-5134; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 06/02/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V1; NLRS_C_description: EasySwitch_Duco; NLRS_C_model: EasySwitch; NLRS_C_revit_versie: 2016; NLRS_C_type: EasySwitch; NLRS_C_type_comments: ‘universele’ plaat; Type Comments: ‘universele’ plaat; Type Name: easyswitch_duco; WT_I BaseKeynote: 31.20
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_x_rgb 000 149 150 T00 groen_gen
Type - Other(Type) - Category: Mechanical Equipment; Family Name: NLRS_57_ME_FB_easyswitch - SH_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.237215 m2; Volume: 0.000470549 m3
Identity Data - Mark: 1
Other - Category: Mechanical Equipment; Family: NLRS_57_ME_FB_easyswitch - SH_duco: easyswitch_duco; Family and Type: NLRS_57_ME_FB_easyswitch - SH_duco: easyswitch_duco; Schedule Level: Level: Level 1; Type: NLRS_57_ME_FB_easyswitch - SH_duco: easyswitch_duco; Type Id: NLRS_57_ME_FB_easyswitch - SH_duco: easyswitch_duco
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
