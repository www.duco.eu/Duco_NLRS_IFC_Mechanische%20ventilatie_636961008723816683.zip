Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:30:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:30:03 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{C4CDCBC7-D73C-49E4-886D-311821E99B13}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:30:02 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:30:02 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:30:02 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcDistributionControlElement: montagestoel hangend_duco, NLRS_59_ME_FB_montagestoel - SH_duco:montagestoel hangend_duco:219396
In: Level 1
Type - Classification: 67.10.10 (Uniformat); Material: NLRS_x_rgb 248 248 248 T00 wit_gen
Type - Constraints(Type) - Default Elevation: 0 mm
Type - Construction(Type) - WT_V Hangend: yes
Type - Dimensions(Type) - NLRS_C_breedte: 740 mm; NLRS_C_diameter: 0 mm; NLRS_C_diepte: 568 mm; NLRS_C_hoogte: 1032 mm
Type - Identity Data(Type) - Assembly Code: 67.10.10; Description: montagestoel hangend_duco; Manufacturer: Duco; Model: montagestoel; NLRS_C_code_artikel: 0000-4422; NLRS_C_code_ETIM: Woonhuisventilator; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010004&classVersion=5; NLRS_C_code_gtin: -; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 20/12/2018; NLRS_C_content_datum_uitgifte: 20/12/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: 1.0.0; NLRS_C_description: montagestoel hangend_duco; NLRS_C_IFC_versie: 2x3; NLRS_C_model: montagestoel; NLRS_C_revit_versie: 2016; NLRS_C_type: hangend; NLRS_C_type_comments: duco_montagestoel hangend; OmniClass Number: 23.75.70.17.37; OmniClass Title: Unit Ventilators; Type Comments: duco_montagestoel hangend; Type Name: montagestoel hangend_duco; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-boxsensor; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_x_rgb 248 248 248 T00 wit_gen
Type - Other(Type) - Category: Mechanical Equipment; Family Name: NLRS_59_ME_FB_montagestoel - SH_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Moves With Nearby Elements: no; Offset: 1 mm
Dimensions - Area: 0.546266 m2; Volume: 0.0125291 m3
Identity Data - Mark: 38
Other - Category: Mechanical Equipment; Family: NLRS_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco; Family and Type: NLRS_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco; Type: NLRS_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco; Type Id: NLRS_59_ME_FB_montagestoel - SH_duco: montagestoel hangend_duco
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco

# IfcEnergyConversionDevice: 460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm, NLRS_57_ME_FB_wtw unit ducobox energy_duco:460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm:219395
In: Level 1
Type - PredefinedType: AIRHANDLER; Classification: 57.21 (Uniformat); Material: NLRS_x_rgb 20 20 20 T00 zwart_gen, NLRS_x_rgb 255 255 255 T00 wit_gen, NLRS_x_rgb 000 149 150 T00 groen_gen
Type - Constraints(Type) - Default Elevation: 1000 mm
Type - Dimensions(Type) - NLRS_C_breedte: 740 mm; NLRS_C_diepte: 585 mm; NLRS_C_hoogte: 957 mm
Type - Electrical(Type) - NLRS_E_c01_aantal_polen: 1; NLRS_E_c01_arbeidsfactor: 1; NLRS_E_c01_belastingsklasse: HVAC; NLRS_E_c01_schijnbaar_vermogen: 230 W; NLRS_E_c01_spanning: 230 V; NLRS_E_c01_stroom: 1 A; NLRS_E_c01_subklasse_motor: no
Type - Identity Data(Type) - Assembly Code: 57.21; Description: ducobox energy 460-2ZS - links_duco; Manufacturer: Duco; Model: DucoBox Energy; NLRS_C_code_artikel: 0000-4362; NLRS_C_code_ETIM: WTW apparaat eengezinswoning; NLRS_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC011285&classVersion=3; NLRS_C_code_gtin: -; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 20/12/2018; NLRS_C_content_datum_uitgifte: 20/12/2018; NLRS_C_content_provider: Duco; NLRS_C_content_versie: 1.0.0; NLRS_C_description: ducobox energy 460-2ZS - links_duco; NLRS_C_model: DucoBox Energy; NLRS_C_revit_versie: 2016; NLRS_C_type: 460-2ZS - links; NLRS_C_type_comments: -; OmniClass Number: 3A(57.31.11); Type Comments: -; Type Name: 460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm; WT_I BaseKeynote: 57.21
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_x_rgb 000 149 150 T00 groen_gen; NLRS_C_materiaal_01: NLRS_x_rgb 000 149 150 T00 groen_gen; NLRS_C_materiaal_02: NLRS_x_rgb 255 255 255 T00 wit_gen; NLRS_C_materiaal_03: NLRS_x_rgb 20 20 20 T00 zwart_gen; WT_V Maintenance zones_materiaal: NLRS_x_rgb 255 0 0 T80 rood_gen
Type - Mechanical(Type) - WT_V Capaciteit: 4.51243 m3/s; WT_V Opvoerhoogte: 150 Pa
Type - Model Properties(Type) - WT_I Afvoercapaciteit bij 150 Pa: 460 m³/h; WT_I Binnendiameter: 160 mm; WT_I Buitendiameter: 190 mm; WT_I Energieklasse: A+; WT_I Gewicht: 47 kg; WT_I Heater: n.v.t.; WT_I Piekvermogen: 2 x 58 W; WT_I Zoneregeling: 1 zone
Type - Other(Type) - Category: Mechanical Equipment; Family Name: NLRS_57_ME_FB_wtw unit ducobox energy_duco; NLRS_E_c01_omschrijving: c01_Elektrische aansluiting; NLRS_E_c02_omschrijving: c02_Communication aansluiting; NLRS_M_c01_diameter: 160 mm; NLRS_M_c01_omschrijving: c01_afvoer naar buiten_EHA; NLRS_M_c02_diameter: 160 mm; NLRS_M_c02_omschrijving: c02_toevoer van buiten_ODA; NLRS_M_c03_diameter: 160 mm; NLRS_M_c03_omschrijving: c03_afvoer van binnen_ETA; NLRS_M_c04_diameter: 160 mm; NLRS_M_c04_omschrijving: c04_toevoer naar binnen_SUP 1; NLRS_M_c05_diameter: 160 mm; NLRS_M_c05_omschrijving: c05_toevoer naar binnen_SUP 2; NLRS_P_c03_belastingswaarde: 0; NLRS_P_c03_diameter: 32 mm; NLRS_P_c03_omschrijving: c01_ condensafvoer; WT_V M_c01_rotatie uit vlak: 0 deg; WT_V M_c01_vlak: 4; WT_V M_c01_X: -248 mm; WT_V M_c01_Y: -141 mm; WT_V M_c01_Z: -50 mm; WT_V M_c02_rotatie uit vlak: 0 deg; WT_V M_c02_vlak: 4; WT_V M_c02_X: 57 mm; WT_V M_c02_Y: -141 mm; WT_V M_c02_Z: -50 mm; WT_V M_c03_rotatie uit vlak: 45 deg; WT_V M_c03_vlak: 4; WT_V M_c03_X: 289 mm; WT_V M_c03_Y: -141 mm; WT_V M_c03_Z: -131.6 mm; WT_V M_c04_rotatie uit vlak: 45 deg; WT_V M_c04_vlak: 4; WT_V M_c04_X: 289 mm; WT_V M_c04_Y: 141 mm; WT_V M_c04_Z: -131.6 mm; WT_V M_c05_rotatie uit vlak: 0 deg; WT_V M_c05_vlak: 4; WT_V M_c05_X: 57 mm; WT_V M_c05_Y: 141 mm; WT_V M_c05_Z: -50 mm; WT_V P_c03_rotatie uit vlak: 0 deg; WT_V P_c03_vlak: 3; WT_V P_c03_X: 258 mm; WT_V P_c03_Y: 138 mm; WT_V P_c03_Z: -10 mm
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: 460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Coax kabel: no; WT_V Communication Print: no; WT_V Communication Print_zichtbaar: no; WT_V Platte sifon: no; WT_V Vocht boxsensor: no
Dimensions - Area: 28.8043 m2; Volume: 7.53427 m3
Graphics - WT_V Onderhoudszone zichtbaar: no
Identity Data - Mark: 37
Mechanical - System Classification: Exhaust Air,Supply Air,Return Air,Supply Air,Sanitary,Power,Communication,Supply Air
Mechanical - Flow - NLRS_M_debiet: 0 m3/s
Other - Category: Mechanical Equipment; Family: NLRS_57_ME_FB_wtw unit ducobox energy_duco: 460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm; Family and Type: NLRS_57_ME_FB_wtw unit ducobox energy_duco: 460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm; NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c02_debiet: 0 m3/s; NLRS_M_c03_debiet: 0 m3/s; NLRS_M_c04_debiet: 0 m3/s; NLRS_M_c05_debiet: 0 m3/s; Schedule Level: Level: Level 1; Type: NLRS_57_ME_FB_wtw unit ducobox energy_duco: 460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm; Type Id: NLRS_57_ME_FB_wtw unit ducobox energy_duco: 460-2zs - links - montagestoel hangend_duco_ducobox energy_bxhxd 740x957x585 mm
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
