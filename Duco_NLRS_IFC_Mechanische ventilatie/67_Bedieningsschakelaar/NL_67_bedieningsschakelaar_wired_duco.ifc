Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-03T00:32:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 03 00:32:07 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{9568E301-CFC0-46A8-8DFC-5DC1A764C6AB}\ifc * Database version: 5507 * Database creation date: Thu Jan 03 00:32:05 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 03 00:32:05 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 03 00:32:05 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcBuildingElementProxy: connector electrical_gen, NLRS_XX_GM_FB_connector electrical_gen:connector electrical_gen:202773
In: Level 1
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Identity Data(Type) - NLRS_C_description: connector electrical_gen; Type Name: connector electrical_gen
Type - Other(Type) - Category: Communication Devices; Family Name: NLRS_XX_GM_FB_connector electrical_gen
Pset_BuildingElementProxyCommon - Reference: connector electrical_gen
Dimensions - Area: 0.0000942373 m2; Volume: 7.85051e-08 m3
Electrical - NLRS_E_c02_aantal_polen: 1; NLRS_E_c02_arbeidsfactor: 1; NLRS_E_c02_belastingsklasse: HVAC; NLRS_E_c02_subklasse_motor: no; NLRS_E_c02_spanning: 24 V; NLRS_E_vermogen: 1 W
Electrical - Circuiting - Electrical Data: c2_elektrische connector 24 V/1-1 VA
Identity Data - Mark: 2
Other - Category: Communication Devices; Family: NLRS_XX_GM_FB_connector electrical_gen: connector electrical_gen; Family and Type: NLRS_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type: NLRS_XX_GM_FB_connector electrical_gen: connector electrical_gen; Type Id: NLRS_XX_GM_FB_connector electrical_gen: connector electrical_gen; WT_c1 Omschrijving: c2_elektrische connector; WT_c2 utility: no
Phasing - Phase Created: New Construction

# IfcDistributionControlElement: wired_duco_bedieningsschakelaar, NLRS_67_COM_FB_bedieningsschakelaar_duco:wired_duco_bedieningsschakelaar:202771
In: Level 1
Type - Classification: 67.1 (Uniformat); Material: NLRS_n_plastic_wit, NLRS_n_plastic_zwart
Type - Constraints(Type) - Default Elevation: 1200 mm
Type - Construction(Type) - WT_V Dikte afdekkader: 20 mm; WT_V Inbouwdiepte: 40 mm
Type - Dimensions(Type) - NLRS_C_breedte: 83 mm; NLRS_C_dikte: 60 mm; NLRS_C_hoogte: 83 mm
Type - Electrical(Type) - NLRS_E_c02_aantal_polen: 1; NLRS_E_c02_actief_vermogen: 1 W; NLRS_E_c02_arbeidsfactor: 1; NLRS_E_c02_belastingsklasse: HVAC; NLRS_E_c02_spanning: 24 V; NLRS_E_c02_subklasse_motor: no; WT_I Stand-By vermogen: 0.5 W
Type - Identity Data(Type) - Assembly Code: 67.1; Description: wired_duco_bedieningschakelaar; Manufacturer: Duco; Model: bedieningsschakelaar; NLRS_C_code_ETIM: Bedieningselement /centraalplaat schakelmateriaal; NLRS_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC000011&classVersion=6; NLRS_C_code_fabrikant_product: 0000-4177; NLRS_C_code_gtin: 5 4 2503715 010 1; NLRS_C_content_creator: ThorbiQ nv; NLRS_C_content_datum_gewijzigd: 23/03/2018; NLRS_C_content_datum_uitgifte: 26/02/2016; NLRS_C_content_provider: Duco; NLRS_C_content_versie: V5; NLRS_C_description: wired_duco_bedieningschakelaar; NLRS_C_model: bedieningsschakelaar; NLRS_C_revit_versie: 2016; NLRS_C_type: wired; NLRS_C_type_comments: bedieningsschakelaar; Type Comments: bedieningsschakelaar; Type Name: wired_duco_bedieningsschakelaar; URL: http://www.duco.eu/nl-nl-producten/nl-nl-ventilatiesystemen/nl-nl-sturingscomponenten/nl-nl-bedieningsschakelaar; WT_I BaseKeynote: 67.10.10
Type - Materials and Finishes(Type) - NLRS_C_materiaal: NLRS_n_plastic_wit
Type - Model Properties(Type) - WT_I Inbouwdoos_diepte: 40 mm; WT_I Kleurenindicatie LED_BLAUW: Visualisatie van de bedieningsschakelaar wanneer er wijzigingen doorgevoerd worden via de DucoBox; WT_I Kleurenindicatie LED_GEEL_knipperen: Overgangsfase (indien DucoBox niet in bereik); WT_I Kleurenindicatie LED_GROEN_snel knipperen: In netwerk en wachtend op onderliggende componenten (bvb. elektronische roosters); WT_I Kleurenindicatie LED_GROEN_traag knipperen: In netwerk; WT_I Kleurenindicatie LED_ROOD_snel knipperen: Bezig met aanmelden; WT_I Kleurenindicatie LED_ROOD_traag knipperen: Niet in netwerk; WT_I Kleur omkasting: zwarte bediening; WT_I Protocol: Z-wave; WT_I Type: Wired_24VDC
Type - Other(Type) - Category: Communication Devices; Family Name: NLRS_67_COM_FB_bedieningsschakelaar_duco; NLRS_E_c01_omschrijving: c1_communication connector; NLRS_E_c02_omschrijving: c2_elektrische connector
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.0170067 m2; Volume: 0.000419885 m3
Graphics - WT_V Positie annotatie x: 0; WT_V Positie annotatie y: 0; WT_V Verschuiving annotatie x: 0 mm; WT_V Verschuiving annotatie y: 0 mm
Identity Data - Mark: 1
Other - Category: Communication Devices; Family: NLRS_67_COM_FB_bedieningsschakelaar_duco: wired_duco_bedieningsschakelaar; Family and Type: NLRS_67_COM_FB_bedieningsschakelaar_duco: wired_duco_bedieningsschakelaar; Schedule Level: Level: Level 1; Type: NLRS_67_COM_FB_bedieningsschakelaar_duco: wired_duco_bedieningsschakelaar; Type Id: NLRS_67_COM_FB_bedieningsschakelaar_duco: wired_duco_bedieningsschakelaar
Phasing - Phase Created: New Construction
Text - NLRS_C_content_handleiding: http://www.witas.be/nl/duco
